/*
 * Brig Receiver ESP32 Firmware
 * Runs inside picsimlab simulator
 * Interfaces with ngspice Touchstone antenna models via UART
 *
 * Target: ESP32-DevKitC
 * Build: PlatformIO or Arduino IDE
 * Mode: Headless autostart with picsimlab
 */

#include <Arduino.h>
#include <SPI.h>
#include <WiFi.h>

// === Antenna Channel Definitions ===
// These match the ngspice Touchstone models and FMU parameters

typedef enum {
    ANT_CH_A = 0,  // 0-900 MHz
    ANT_CH_B = 1,  // 1.2-3 GHz
    ANT_CH_C = 2   // 4-7 GHz
} antenna_channel_t;

// Channel parameters (from FDTD/ngspice validation)
static const struct {
    antenna_channel_t ch;
    const char *name;
    float f_res_hz;      // Resonant frequency
    float s11_db;        // S11 at resonance
    float eta_rad;       // Radiation efficiency
    float bw_hz;         // Bandwidth (contiguous matched)
    float gain_linear;   |S21|^2 at resonance
} antenna_ch_params[] = {
    {ANT_CH_A, "Ch A (0-900 MHz)", 200000000.0, -12.0, 1.0, 10000000, 0.937},   // 0.9679^2
    {ANT_CH_B, "Ch B (1.2-3 GHz)", 2450000000.0, -33.1, 0.304, 47800000, 0.091},  // 0.3018^2
    {ANT_CH_C, "Ch C (4-7 GHz)", 5800000000.0, -24.4, 0.496, 131900000, 0.247}     // 0.4972^2
};

// Current selected channel
static antenna_channel_t current_ch = ANT_CH_A;

// === ngspice / FMU Co-Simulation Interface ===
// The firmware sends antenna parameters over UART to a Python bridge
// that connects to the ngspice/fmpy co-simulation loop.

// UART buffer for co-simulation data
#define UART_BUFFER_SIZE 256
static uint8_t uart_rx_buffer[UART_BUFFER_SIZE];
static uint8_t uart_tx_buffer[UART_BUFFER_SIZE];
static volatile uint16_t uart_rx_head = 0;
static volatile uint16_t uart_rx_tail = 0;
static volatile uint16_t uart_tx_head = 0;
static volatile uint16_t uart_tx_tail = 0;

// === PIN Switch Control for Antenna Arrays ===
// The Brig Receiver uses PIN diodes to switch between antenna channels
// These GPIO pins connect to the PCB PIN switch networks

#define PIN_SW_A 5   // GPIO5  - Select Channel A
#define PIN_SW_B 18  // GPIO18 - Select Channel B
#define PIN_SW_C 19  // GPIO19 - Select Channel C
#define PIN_SW_ENABLE 21  // GPIO21 - PIN diode enable

// PIN switch state machine
static uint8_t pin_sw_state = 0;  // 0=disable, 1=A, 2=B, 3=C

void pin_sw_init(void) {
    pinMode(PIN_SW_A, OUTPUT);
    pinMode(PIN_SW_B, OUTPUT);
    pinMode(PIN_SW_C, OUTPUT);
    pinMode(PIN_SW_ENABLE, OUTPUT);
    pin_sw_disable();
}

void pin_sw_select(antenna_channel_t ch) {
    // Disable all first
    digitalWrite(PIN_SW_ENABLE, LOW);
    
    switch (ch) {
        case ANT_CH_A:
            digitalWrite(PIN_SW_A, HIGH);
            digitalWrite(PIN_SW_B, LOW);
            digitalWrite(PIN_SW_C, LOW);
            break;
        case ANT_CH_B:
            digitalWrite(PIN_SW_A, LOW);
            digitalWrite(PIN_SW_B, HIGH);
            digitalWrite(PIN_SW_C, LOW);
            break;
        case ANT_CH_C:
            digitalWrite(PIN_SW_A, LOW);
            digitalWrite(PIN_SW_B, LOW);
            digitalWrite(PIN_SW_C, HIGH);
            break;
        default:
            pin_sw_disable();
            break;
    }
    pin_sw_state = (ch == ANT_CH_A) ? 1 : (ch == ANT_CH_B) ? 2 : 3;
    digitalWrite(PIN_SW_ENABLE, HIGH);
}

void pin_sw_disable(void) {
    digitalWrite(PIN_SW_A, LOW);
    digitalWrite(PIN_SW_B, LOW);
    digitalWrite(PIN_SW_C, LOW);
    digitalWrite(PIN_SW_ENABLE, LOW);
    pin_sw_state = 0;
}

// === Antenna Parameter Structure ===
// These are updated from ngspice/fmpy co-simulation via UART
typedef struct {
    float s11_db;
    float eta_rad;
    float freq_hz;
    float abs_s21;  // |S21| at resonance
    float delta_n;  // From BraggBlock FMU
    uint32_t timestamp;
} antenna_params_t;

static antenna_params_t current_params = {
    .s11_db = -12.0,
    .eta_rad = 1.0,
    .freq_hz = 200000000.0,
    .abs_s21 = 0.9679,
    .delta_n = 0.0,
    .timestamp = 0
};

// === WiFi Parameters ===
const char* ssid = "BRIG_RECEIVER";
const char* password = "sdr2026";

// WiFi status
static uint8_t wifi_status = WL_IDLE_STATUS;

// === Setup ===
void setup() {
    // Initialize serial for picsimlab host communication
    Serial.begin(115200);
    
    // Wait for serial port to connect (for native USB)
    while (!Serial) {
        delay(10);
    }
    
    // Initialize PIN switch control
    pin_sw_init();
    
    // Select default channel (A)
    pin_sw_select(ANT_CH_A);
    current_ch = ANT_CH_A;
    
    // Initialize antenna parameters from defaults
    // In normal operation, these would be received via UART from the ngspice bridge
    
    // WiFi setup (optional - for data output)
    WiFi.mode(WIFI_STA);
    WiFi.disconnect();
    delay(100);
    
    // Signal picsimlab that firmware is ready
    Serial.println("BRIG_RECEIVER_ESP32_READY");
    Serial.println("VERSION:1.0");
    Serial.println("CO_SIM:ACTIVE");
    
    // Log initialization
    Serial.println("=== Brig Receiver ESP32 Firmware ===");
    Serial.print("Channel A: f_res="); Serial.println(antenna_ch_params[0].f_res_hz);
    Serial.print("Channel B: f_res="); Serial.println(antenna_ch_params[1].f_res_hz);
    Serial.print("Channel C: f_res="); Serial.println(antenna_ch_params[2].f_res_hz);
    Serial.println("==================================");
}

// === Loop ===
void loop() {
    // Handle UART input from ngspice bridge
    handle_uart();
    
    // Handle PIN switch changes (could be triggered by UART commands or timer)
    // In picsimlab, this could be driven by the simulator's GPIO events
    
    // Periodically transmit antenna parameters over UART
    static unsigned long last_tx = 0;
    unsigned long now = millis();
    if (now - last_tx >= 100) {  // 10 Hz telemetry
        last_tx = now;
        transmit_antenna_params();
    }
    
    // WiFi handling (optional)
    handle_wifi();
    
    // Small delay to prevent watchdog issues
    delay(1);
}

// === UART Handler ===
void handle_uart(void) {
    while (Serial.available() > 0) {
        uint8_t byte = Serial.read();
        uart_rx_buffer[uart_rx_head] = byte;
        uart_rx_head = (uart_rx_head + 1) % UART_BUFFER_SIZE;
        
        // Process complete lines
        if (byte == '
' || byte == '
') {
            uart_rx_buffer[uart_rx_head] = '';
            process_uart_command(&uart_rx_buffer[uart_rx_tail]);
            uart_rx_tail = (uart_rx_tail + 1) % UART_BUFFER_SIZE;
        }
    }
}

// === Process UART Command ===
// Commands from ngspice bridge:
//   CHSEL <0|1|2>   - Select antenna channel
//   GET_PARAM       - Request current antenna parameters
//   SET_PARAM s11 eta freq  - Update antenna parameters
//   GET_DELTA_N     - Request delta_n from BraggBlock FMU
void process_uart_command(uint8_t *cmd) {
    // Find command string
    char *ptr = (char *)cmd;
    // Remove trailing newline/carriage return
    while (*ptr && *ptr != '
' && *ptr != '
') ptr++;
    *ptr = '';
    
    // Skip leading whitespace
    while (*cmd == ' ') cmd++;
    
    if (strncmp(cmd, "CHSEL", 5) == 0) {
        // Select antenna channel
        int ch = atoi(cmd + 6);
        if (ch >= 0 && ch <= 2) {
            pin_sw_select((antenna_channel_t)ch);
            current_ch = (antenna_channel_t)ch;
            Serial.print("CHANNEL_SELECTED:");
            Serial.println(cmd + 6);
        } else {
            Serial.println("ERROR: Channel must be 0, 1, or 2");
        }
    }
    else if (strncmp(cmd, "GET_PARAM", 9) == 0) {
        // Send current antenna parameters
        transmit_antenna_params();
    }
    else if (strncmp(cmd, "SET_PARAM", 9) == 0) {
        // Set antenna parameters from ngspice
        // Format: SET_PARAM s11_db eta freq_hz
        char *arg = cmd + 10;
        float s11, eta, freq;
        if (sscanf(arg, "%f %f %f", &s11, &eta, &freq) == 3) {
            current_params.s11_db = s11;
            current_params.eta_rad = eta;
            current_params.freq_hz = freq;
            Serial.println("PARAMETERS_UPDATED");
        } else {
            Serial.println("ERROR: Format: SET_PARAM s11 eta freq");
        }
    }
    else if (strncmp(cmd, "GET_DELTA_N", 11) == 0) {
        // Request delta_n from BraggBlock FMU co-simulation
        // This would be obtained from the FMU engine
        Serial.print("DELTA_N:");
        Serial.println(current_params.delta_n, 10);
    }
    else if (strncmp(cmd, "VERSION", 7) == 0) {
        Serial.println("BRIG_RECEIVER_ESP32_VERSION:1.0");
        Serial.println("CO_SIM_INTERFACE:FMU_FMPY");
    }
    else {
        Serial.print("UNKNOWN_COMMAND:");
        Serial.println(cmd);
    }
}

// === Transmit Antenna Parameters ===
void transmit_antenna_params(void) {
    // Format: PARAM s11_db eta freq_hz abs_s21 delta_n
    // All values come from the ngspice/fmpy co-simulation
    Serial.print("PARAM ");
    Serial.print(current_params.s11_db, 2);
    Serial.print(" ");
    Serial.print(current_params.eta_rad, 3);
    Serial.print(" ");
    Serial.print(current_params.freq_hz, 1);
    Serial.print(" ");
    Serial.print(current_params.abs_s21, 3);
    Serial.print(" ");
    Serial.println(current_params.delta_n, 8);
}

// === WiFi Handler ===
void handle_wifi(void) {
    // Optional WiFi handling for data output
    // In picsimlab headless mode, WiFi may not be available
    // but the firmware structure supports it
    if (WiFi.status() != WL_CONNECTED) {
        // Periodic WiFi reconnect attempt
        static unsigned long last_wifi = 0;
        if (millis() - last_wifi > 60000) {  // Every minute
            last_wifi = millis();
            WiFi.disconnect();
            WiFi.mode(WIFI_STA);
            WiFi.begin(ssid, password);
        }
    }
}

// === External Functions (called from picsimlab or Python bridge) ===
// These allow the Python co-simulation to update antenna parameters

// Update antenna parameters from ngspice/fmpy co-simulation
void update_antenna_params(float s11_db, float eta_rad, float freq_hz, float abs_s21, float delta_n) {
    current_params.s11_db = s11_db;
    current_params.eta_rad = eta_rad;
    current_params.freq_hz = freq_hz;
    current_params.abs_s21 = abs_s21;
    current_params.delta_n = delta_n;
    current_params.timestamp = millis();
    
    // Echo back for verification
    Serial.print("PARAM_UPDATE s11=");
    Serial.print(s11_db);
    Serial.print(" eta=");
    Serial.print(eta_rad);
    Serial.print(" freq=");
    Serial.print(freq_hz/1e9, 2);
    Serial.print("GHz s21=");
    Serial.print(abs_s21, 3);
    Serial.print(" delta_n=");
    Serial.println(delta_n, 8);
}

// Get current channel
antenna_channel_t get_current_channel(void) {
    return current_ch;
}

// Get current antenna parameters
antenna_params_t get_antenna_params(void) {
    return current_params;
}

// === picsimlab Compatibility Functions ===
// picsimlab may call these functions during simulation

// called by picsimlab at each simulation step
void picsimlab_step(uint32_t step_count) {
    // Could be used to update state at each picsimlab step
    // For now, just acknowledge the step
    // (step_count is the simulated time step counter)
}

// called by picsimlab when firmware is loading
void picsimlab_loaded(void) {
    // Firmware has been loaded into picsimlab simulator
    // Initialize or reset state here
    pin_sw_disable();
    current_ch = ANT_CH_A;
}

// called by picsimlab when firmware is unloading
void picsimlab_unloaded(void) {
    // Clean up before firmware unload
    pin_sw_disable();
}
